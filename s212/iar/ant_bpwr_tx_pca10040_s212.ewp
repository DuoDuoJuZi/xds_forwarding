# IAR project ant_bpwr_tx_pca10040_s212.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; S212; SOFTDEVICE_PRESENT
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\config; D:\nRF5_SDK_17.1.0\components; D:\nRF5_SDK_17.1.0\components\ant\ant_channel_config; D:\nRF5_SDK_17.1.0\components\ant\ant_key_manager; D:\nRF5_SDK_17.1.0\components\ant\ant_key_manager\config; D:\nRF5_SDK_17.1.0\components\ant\ant_profiles\ant_bpwr; D:\nRF5_SDK_17.1.0\components\ant\ant_profiles\ant_bpwr\pages; D:\nRF5_SDK_17.1.0\components\ant\ant_profiles\ant_bpwr\simulator; D:\nRF5_SDK_17.1.0\components\ant\ant_profiles\ant_bpwr\utils; D:\nRF5_SDK_17.1.0\components\ant\ant_profiles\ant_common\pages; D:\nRF5_SDK_17.1.0\components\ant\ant_state_indicator; D:\nRF5_SDK_17.1.0\components\boards; D:\nRF5_SDK_17.1.0\components\libraries\atomic; D:\nRF5_SDK_17.1.0\components\libraries\atomic_fifo; D:\nRF5_SDK_17.1.0\components\libraries\balloc; D:\nRF5_SDK_17.1.0\components\libraries\bsp; D:\nRF5_SDK_17.1.0\components\libraries\button; D:\nRF5_SDK_17.1.0\components\libraries\delay; D:\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars; D:\nRF5_SDK_17.1.0\components\libraries\hardfault; D:\nRF5_SDK_17.1.0\components\libraries\hardfault\nrf52; D:\nRF5_SDK_17.1.0\components\libraries\log; D:\nRF5_SDK_17.1.0\components\libraries\log\src; D:\nRF5_SDK_17.1.0\components\libraries\memobj; D:\nRF5_SDK_17.1.0\components\libraries\mutex; D:\nRF5_SDK_17.1.0\components\libraries\pwr_mgmt; D:\nRF5_SDK_17.1.0\components\libraries\ringbuf; D:\nRF5_SDK_17.1.0\components\libraries\scheduler; D:\nRF5_SDK_17.1.0\components\libraries\sensorsim; D:\nRF5_SDK_17.1.0\components\libraries\sortlist; D:\nRF5_SDK_17.1.0\components\libraries\strerror; D:\nRF5_SDK_17.1.0\components\libraries\timer; D:\nRF5_SDK_17.1.0\components\libraries\util; D:\nRF5_SDK_17.1.0\components\softdevice\common; D:\nRF5_SDK_17.1.0\components\softdevice\s212\headers; D:\nRF5_SDK_17.1.0\components\softdevice\s212\headers\nrf52; D:\nRF5_SDK_17.1.0\components\toolchain\cmsis\include; D:\nRF5_SDK_17.1.0\external\fprintf; D:\nRF5_SDK_17.1.0\external\segger_rtt; D:\nRF5_SDK_17.1.0\integration\nrfx; D:\nRF5_SDK_17.1.0\integration\nrfx\legacy; D:\nRF5_SDK_17.1.0\modules\nrfx; D:\nRF5_SDK_17.1.0\modules\nrfx\drivers\include; D:\nRF5_SDK_17.1.0\modules\nrfx\hal; D:\nRF5_SDK_17.1.0\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ant_bpwr_tx_pca10040_s212.hex
  ILINK.IlinkOutputFile: ant_bpwr_tx_pca10040_s212.out
  ILINK.IlinkIcfFile: ant_bpwr_tx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    D:/nRF5_SDK_17.1.0/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    D:/nRF5_SDK_17.1.0/components/boards/: boards.c
  group nRF_Libraries
    D:/nRF5_SDK_17.1.0/components/libraries/button/: app_button.c
    D:/nRF5_SDK_17.1.0/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    D:/nRF5_SDK_17.1.0/components/libraries/scheduler/: app_scheduler.c
    D:/nRF5_SDK_17.1.0/components/libraries/timer/: app_timer2.c drv_rtc.c
    D:/nRF5_SDK_17.1.0/components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    D:/nRF5_SDK_17.1.0/components/libraries/hardfault/: hardfault_implementation.c
    D:/nRF5_SDK_17.1.0/components/libraries/atomic_fifo/: nrf_atfifo.c
    D:/nRF5_SDK_17.1.0/components/libraries/atomic/: nrf_atomic.c
    D:/nRF5_SDK_17.1.0/components/libraries/balloc/: nrf_balloc.c
    D:/nRF5_SDK_17.1.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    D:/nRF5_SDK_17.1.0/components/libraries/memobj/: nrf_memobj.c
    D:/nRF5_SDK_17.1.0/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    D:/nRF5_SDK_17.1.0/components/libraries/ringbuf/: nrf_ringbuf.c
    D:/nRF5_SDK_17.1.0/components/libraries/experimental_section_vars/: nrf_section_iter.c
    D:/nRF5_SDK_17.1.0/components/libraries/sortlist/: nrf_sortlist.c
    D:/nRF5_SDK_17.1.0/components/libraries/strerror/: nrf_strerror.c
    D:/nRF5_SDK_17.1.0/components/libraries/sensorsim/: sensorsim.c
  group nRF_Drivers
    D:/nRF5_SDK_17.1.0/integration/nrfx/legacy/: nrf_drv_uart.c
    D:/nRF5_SDK_17.1.0/modules/nrfx/soc/: nrfx_atomic.c
    D:/nRF5_SDK_17.1.0/modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    D:/nRF5_SDK_17.1.0/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_ANT
    D:/nRF5_SDK_17.1.0/components/ant/ant_profiles/ant_bpwr/: ant_bpwr.c
    D:/nRF5_SDK_17.1.0/components/ant/ant_profiles/ant_bpwr/pages/: ant_bpwr_common_data.c ant_bpwr_page_1.c ant_bpwr_page_16.c ant_bpwr_page_17.c ant_bpwr_page_18.c ant_bpwr_page_torque.c
    D:/nRF5_SDK_17.1.0/components/ant/ant_profiles/ant_bpwr/simulator/: ant_bpwr_simulator.c
    D:/nRF5_SDK_17.1.0/components/ant/ant_channel_config/: ant_channel_config.c
    D:/nRF5_SDK_17.1.0/components/ant/ant_profiles/ant_common/pages/: ant_common_page_80.c ant_common_page_81.c
    D:/nRF5_SDK_17.1.0/components/ant/ant_key_manager/: ant_key_manager.c
    D:/nRF5_SDK_17.1.0/components/ant/ant_state_indicator/: ant_state_indicator.c
  group Board Support
    D:/nRF5_SDK_17.1.0/components/libraries/bsp/: bsp.c
  group Application
    ../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    D:/nRF5_SDK_17.1.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    D:/nRF5_SDK_17.1.0/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_SoftDevice
    D:/nRF5_SDK_17.1.0/components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c
